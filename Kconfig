## Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0
menu "RGA2"
	depends on ARCH_ROCKCHIP

config ROCKCHIP_RGA2
	tristate "ROCKCHIP_RGA2"
	help
	  Rockchip rga2 module.

endmenu
```
